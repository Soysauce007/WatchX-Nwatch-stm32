# Keil uVision project NWatch.uvprojx, settings and files
target NWatch (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: NWatch +hex
  c flags: Optim=1 uC99=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,__CC_ARM
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\HARDWARE\LCD;..\FWLIB\inc;..\Watch;..\HARDWARE\BEEP;..\HARDWARE\RTC;..\HARDWARE\STMFLASH
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group WATCH
    ../Watch/: animation.c display.c menu.c resources.c global.c draw.c millis.c m_main.c buttons.c normal.c time.c timedate.c ui.c alarm.c alarms.c stopwatch.c game1.c game2.c game3.c games.c torch.c diag.c settings.c m_display.c tunemaker.c tune.c tunes.c sound.c m_rtc.c appconfig.c sleep.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/STMFLASH/: stmflash.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_fsmc.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_rtc.c stm32f4xx_exti.c stm32f4xx_pwr.c stm32f4xx_flash.c
  group README
    ../: readme.txt
